options:
  parameters:
    category: Custom
    description: 'Fixed part of the ISDB-Tb analyzer. Run: the per-layer part is built from the TMCC by isdbt_dynamic.py (via run_dynamic.py, see Run Command).'
    generate_options: qt_gui
    id: stbcast_analyzer_dyn
    output_language: python
    realtime_scheduling: '1'
    run_command: '{python} -u -c "import os,sys,runpy; d=os.path.dirname(os.path.abspath(sys.argv[1])); runpy.run_path(os.path.join(d,''run_dynamic.py''), run_name=''__main__'')" {filename}'
    title: Stbcast Analyzer (dynamic layers)
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'tab_widget_layers@4: 1,0,1,1'
    label: Center frequency (Hz)
    type: int
    value: '473142857'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tab_widget_layers@4: 0,0,1,1'
    label: RX gain (dB)
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: rx_gain_init
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'False'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 8e6
    calibr_bandw_ch0: 8e6
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '3'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab_widget_layers@0
    legend: 'False'
    name: '"Data carriers (all layers)"'
    size: data_carriers
    type: complex
  states: {}
- name: rx_gain_init
  id: parameter
  parameters:
    type: eng_float
    value: '35'
  states: {}
- name: tab_widget_layers
  id: qtgui_tab_widget
  parameters:
    label0: Constellation
    label1: Layer A
    label2: Layer B
    label3: Layer C
    label4: Control
    num_tabs: '5'
  states: {}

connections:
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_tmcc_decoder_0, tmcc, blocks_message_debug_0, print]
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']

metadata:
  file_format: 1
