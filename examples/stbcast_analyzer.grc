options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: stbcast_analyzer
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: active_carriers
  id: variable
  parameters:
    value: 13*108*2**(mode-1)+1
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center freq.
    type: int
    value: '473142857'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: guard
  id: variable
  parameters:
    value: 1.0/16
  states: {}
- name: mode
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: '50'
    value: rx_gain_init
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*64/63
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(10+mode)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ts_layer_b
    type: byte
    unbuffered: 'True'
    vlen: '1316'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/ts_layer_c
    type: byte
    unbuffered: 'True'
    vlen: '1316'
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/ts_layer_a
    type: byte
    unbuffered: 'True'
    vlen: '1316'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '797'
    num_items: '1316'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '797'
    num_items: '1316'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '797'
    num_items: '1316'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '188'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: data_carriers
    type: complex
  states: {}
- name: isdbt_bit_deinterleaver_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: '12'
  states: {}
- name: isdbt_bit_deinterleaver_0_0
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '64'
    mode: '3'
    segments: '0'
  states: {state: disabled}
- name: isdbt_bit_deinterleaver_0_1
  id: isdbt_bit_deinterleaver
  parameters:
    constellation_size: '4'
    mode: '3'
    segments: '1'
  states: {}
- name: isdbt_byte_deinterleaver_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_byte_deinterleaver_0_0
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {state: disabled}
- name: isdbt_byte_deinterleaver_0_1
  id: isdbt_byte_deinterleaver
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_energy_descrambler_0_0
  id: isdbt_energy_descrambler
  parameters: {}
  states: {state: disabled}
- name: isdbt_energy_descrambler_0_1
  id: isdbt_energy_descrambler
  parameters: {}
  states: {}
- name: isdbt_frequency_deinterleaver_0
  id: isdbt_frequency_deinterleaver
  parameters:
    mode: '3'
    oneseg: 'True'
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: '0.0625'
    interpolate: 'False'
    mode: '3'
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_reed_solomon_dec_isdbt_0_0
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {state: disabled}
- name: isdbt_reed_solomon_dec_isdbt_0_1
  id: isdbt_reed_solomon_dec_isdbt
  parameters: {}
  states: {}
- name: isdbt_symbol_demapper_0
  id: isdbt_symbol_demapper
  parameters:
    constellation_size_A: '4'
    constellation_size_B: '64'
    constellation_size_C: '64'
    mode: '3'
    segments_A: '1'
    segments_B: '12'
    segments_C: '0'
  states: {}
- name: isdbt_time_deinterleaver_0
  id: isdbt_time_deinterleaver
  parameters:
    length_A: '1'
    length_B: '2'
    length_C: '0'
    mode: '3'
    segments_A: '1'
    segments_B: '12'
    segments_C: '0'
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: '3'
    print_params: 'True'
  states: {}
- name: isdbt_viterbi_decoder_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '64'
    rate: '2'
  states: {}
- name: isdbt_viterbi_decoder_0_0
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '64'
    rate: '2'
  states: {state: disabled}
- name: isdbt_viterbi_decoder_0_1
  id: isdbt_viterbi_decoder
  parameters:
    constellation_size: '4'
    rate: '2'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 8e6
    calibr_bandw_ch0: 8e6
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '3'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5.8e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab_widget_layers@0
    size: active_carriers
    type: complex
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@2
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi Layer B (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@3
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi Layer C (log10)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@1
    max: '0'
    min: '-35'
    name: '"BER post-Viterbi Layer A (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@2
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi Layer B (log10)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@3
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi Layer C (log10)"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab_widget_layers@1
    max: '0'
    min: '-10'
    name: '"BER pre-Viterbi Layer A (log10)"'
    type: float
  states: {}
- name: rx_gain_init
  id: parameter
  parameters:
    type: eng_float
    value: '35'
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-3'
    type: float
  states: {}
- name: tab_widget_layers
  id: qtgui_tab_widget
  parameters:
    label0: Overview
    label1: Layer A
    label2: Layer B
    label3: Layer C
    num_tabs: '4'
  states: {}

connections:
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_nlog10_ff_0_0_1, '0', qtgui_number_sink_0_1_1, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_nlog10_ff_0_2, '0', qtgui_number_sink_0_0_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_null_sink_1_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_null_sink_1_1, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_const_sink_x_0, '0']
- [isdbt_bit_deinterleaver_0, '0', isdbt_viterbi_decoder_0, '0']
- [isdbt_bit_deinterleaver_0_0, '0', isdbt_viterbi_decoder_0_0, '0']
- [isdbt_bit_deinterleaver_0_1, '0', isdbt_viterbi_decoder_0_1, '0']
- [isdbt_byte_deinterleaver_0, '0', isdbt_energy_descrambler_0, '0']
- [isdbt_byte_deinterleaver_0_0, '0', isdbt_energy_descrambler_0_0, '0']
- [isdbt_byte_deinterleaver_0_1, '0', isdbt_energy_descrambler_0_1, '0']
- [isdbt_energy_descrambler_0, '0', isdbt_reed_solomon_dec_isdbt_0, '0']
- [isdbt_energy_descrambler_0_0, '0', isdbt_reed_solomon_dec_isdbt_0_0, '0']
- [isdbt_energy_descrambler_0_1, '0', isdbt_reed_solomon_dec_isdbt_0_1, '0']
- [isdbt_frequency_deinterleaver_0, '0', isdbt_time_deinterleaver_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '0', blocks_vector_to_stream_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0, '1', blocks_nlog10_ff_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [isdbt_reed_solomon_dec_isdbt_0_0, '1', blocks_nlog10_ff_0_1, '0']
- [isdbt_reed_solomon_dec_isdbt_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [isdbt_reed_solomon_dec_isdbt_0_1, '1', blocks_nlog10_ff_0_2, '0']
- [isdbt_symbol_demapper_0, '0', isdbt_bit_deinterleaver_0_1, '0']
- [isdbt_symbol_demapper_0, '1', isdbt_bit_deinterleaver_0, '0']
- [isdbt_symbol_demapper_0, '2', isdbt_bit_deinterleaver_0_0, '0']
- [isdbt_time_deinterleaver_0, '0', isdbt_symbol_demapper_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_vector_to_stream_0_2, '0']
- [isdbt_tmcc_decoder_0, '0', isdbt_frequency_deinterleaver_0, '0']
- [isdbt_tmcc_decoder_0, tmcc, blocks_message_debug_0, print]
- [isdbt_viterbi_decoder_0, '0', isdbt_byte_deinterleaver_0, '0']
- [isdbt_viterbi_decoder_0, '1', single_pole_iir_filter_xx_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '0', isdbt_byte_deinterleaver_0_0, '0']
- [isdbt_viterbi_decoder_0_0, '1', single_pole_iir_filter_xx_0_0_0, '0']
- [isdbt_viterbi_decoder_0_1, '0', isdbt_byte_deinterleaver_0_1, '0']
- [isdbt_viterbi_decoder_0_1, '1', single_pole_iir_filter_xx_0_0_1, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [single_pole_iir_filter_xx_0_0_1, '0', blocks_nlog10_ff_0_0_1, '0']

metadata:
  file_format: 1
